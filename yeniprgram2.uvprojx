# Keil uVision project yeniprgram2.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: STM32F410RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: yeniprgram2
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=9 wLevel=3
  c include: .;.\App\Inc;.\Services\Inc;.\Drivers\Inc;.\Legacy\Inc;.\Config\Inc;.\Common\Inc;.\RTE;.\RTE\Device\STM32F410RBTx;.\RTE\_Target_1
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Project\stm32f410.sct
  group Source Group 1
    ./Legacy/Inc/: delay.h i2c.h lcd.h modbus_rtu.h pwm.h sht3x.h sysclock.h uart.h filter.h adc.h error_check.h sensor_task.h watchdog.h
    ./App/Src/: main.cpp Application.cpp ConfigManager.cpp
    ./Legacy/Src/: sysclock.cpp interrupts.cpp filter.cpp flash_write.cpp uart.cpp i2c.cpp
    ./Config/Inc/: Config_Manager.h appcons.h apptdef.h sensortypes.h
    ./Drivers/Src/: DelayTimer.cpp SystemClockFacade.cpp I2cBus.cpp Sht3xSensor.cpp LcdDisplay.cpp PwmOutput.cpp SpiBus.cpp
    ./Services/Src/: AdcService.cpp ModbusService.cpp WatchdogService.cpp ErrorManager.cpp FlashStorage.cpp SensorService.cpp
    ./Config/Src/: config_manager.c
    ./App/Inc/: main.hpp
    ./Drivers/Inc/: SpiBus.hpp
software components: CMSIS:CORE 5.2.0, Device:Startup 2.6.3
